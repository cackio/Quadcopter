# Keil uVision project aaa.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: aaa
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Cfg;..\Core;..\Port;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Core\Inc;..\Core\Src;..\User;..\BSP-Self;..\APP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Core
    ../Core/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.c os.h os_trace.h ucos_ii.h
  group Port
    ../Port/: os_cpu_c.c os_cpu.h os_cpu_a.s
  group Cfg
    ../Cfg/: app_cfg.h os_cfg.h
  group Start
    ../Start/: startup_stm32f401xe.s
  group User
    ../User/: main.c led.c led.h
  group Drivers
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
    ../Core/Src/: system_stm32f4xx.c
  group BSP-Self
    ../BSP-Self/: BSP.c BSP.h
  group APP
    ../APP/: includes.h gpio.c i2c.c usart.c gpio.h i2c.h usart.h
