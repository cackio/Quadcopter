# Keil uVision project uCOS-II.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: uCOS-II +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Cfg;..\Core;..\Port;..\User
  asm include: ..\Start;..\Port;..\Cfg;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Core
    ../Core/: os.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.c ucos_ii.h
  group Port
    ../Port/: os_cpu.h os_cpu_c.c os_cpu_a.s
  group Cfg
    ../Cfg/: app_cfg.h os_cfg.h
  group User
    ../User/: main.c led.c led.h
  group Start
    ../Start/: startup_stm32f401xe.s
